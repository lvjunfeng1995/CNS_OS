# Keil uVision project CNS_OS.uvprojx, settings and files
target CNS_OS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CNS_OS +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\CORE;.\USER;.\STM32F10x_FWLib\inc;.\ND_OS;.\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CORE
    ./CORE/: core_cm3.c startup_stm32f10x_hd.s
  group USER
    ./USER/: system_stm32f10x.c stm32f10x_it.c main.c TimeSet.c sys.c comunication.c Rhd2000.c
  group FWLIB
    ./STM32F10x_FWLib/src/: stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_flash.c misc.c
  group NDOS
    ./ND_OS/: nd_os_core.c nd_os_mem.c nd_os_msg.c nd_os_prio.c nd_os_queue.c nd_os_sem.c nd_os_table.c nd_os_task.c nd_os_cpu.s nd_os_event.c
  group BSP
    ./BSP/: ND_OS_BSP.c usart.c spi.c timer.c systic.c
